# Keil uVision project RAK811.uvprojx, settings and files
target RAK5205_HF (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RAK811_HF_trackerboard_V2.0.1.
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: HAL_IWDG_MODULE_ENABLED TRACKERBOARD LORA_HF_BOARD
  c include: ..\..\..\src\application\RAK811;..\..\..\src\external\JSON;..\..\..\src\external\utilities;..\..\..\src\hal\cmsis;..\..\..\src\hal\STM32L1xx_HAL_Driver\Inc;..\..\..\src\hal\STM32L1xx_HAL_Driver\Inc\Legacy;..\..\..\src\LoRaWAN\master\mac;..\..\..\src\LoRaWAN\master\mac\region;..\..\..\src\LoRaWAN\master\radio;..\..\..\src\LoRaWAN\master\radio\sx1276;..\..\..\src\LoRaWAN\master\system;..\..\..\src\LoRaWAN\master\system\crypto;..\..\..\src\board\RAK811;..\..\..\src\board\RAK811\cmsis;..\..\..\src\driver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../../src/application/RAK811/: app.c at_cmd.c lora_config.c partition.c rw_lora.c main.c
  group board
    ../../../src/board/RAK811/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx127X-board.c timer-board.c uart-board.c BME680-board.c BME680-selftest.c
    ../../../src/board/RAK811/cmsis/: system_stm32l1xx.c
    ../../../src/board/RAK811/cmsis/arm-std/: startup_stm32l1xx_md.s
  group hal
    ../../../src/hal/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group driver
    ../../../src/driver/: lis3dh.c BME680.c
  group external
    ../../../src/external/JSON/: cJSON.c
    ../../../src/external/utilities/: utilities.c
  group LoRaWAN
    ../../../src/LoRaWAN/master/mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../src/LoRaWAN/master/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
    ../../../src/LoRaWAN/master/radio/: sx127x.c
    ../../../src/LoRaWAN/master/system/: adc.c delay.c eeprom.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
    ../../../src/LoRaWAN/master/system/crypto/: aes.c cmac.c
  group doc
    ../../../doc/Firmware/: ReleaseNotes.txt
target RAK5205_LF (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: RAK811_LF_trackerboard_V2.1.1.
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: HAL_IWDG_MODULE_ENABLED TRACKERBOARD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
